options:
  parameters:
    author: migriane
    generate_options: no_gui
    id: ble_decode
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: access_address
  id: variable
  parameters:
    value: '''0x8E89BED6'''
  states: {}
- name: channel_id
  id: variable
  parameters:
    value: '39'
  states: {}
- name: freq_channel
  id: variable
  parameters:
    value: 2.480e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '0.392699'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    AA: access_address
    _source_code: "\"\"\"\nBLE_Packets_Gain Block\n\nThe input data comes from GFSKDemod, which captures BLE air packets according to PREAMBLE and AccessAddress. \nAccording to the longest value of BLE Packets, forward the data to the next module for processing. \n\nKey1: Not descrambled, not calculated PDU length\nKey2: Since the output length of GFSKDemod is 1024 each time, some packets may be truncated,\n      and the module will choose to discard these packets.\n\nParam1: Access Address , ADV (0x8E89BED6) Default\n\n\"\"\"\n\nfrom re import L\nfrom struct import pack\nimport numpy as np\nfrom gnuradio import gr\nfrom array import array\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\" BLE_Packets_Gain Block \"\"\"\n\n    def __init__(self, AA = \"0x8E89BED6\"):  # only default arguments here\n        gr.sync_block.__init__(\n            self,\n            name='BLE PACKET Gain',   # will show up in GRC\n            in_sig=[np.int8],\n            out_sig=None\n        )\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.AccessAddress = AA\n        self.last_packets=\"\"\n\n    def work(self, input_items, output_items):\n        bits_stream=input_items[0]\n        bits_decode=\"\"\n        for x in bits_stream:  \n            bits_decode+=str(x)\n\n        if self.AccessAddress!='':\n            AA =bin(int(self.AccessAddress,base=16))[2:].zfill(8*4)[::-1]\n        else:\n            AA=\"\"\n        PREAMBLE=\"01010101\" # 0xaa reverse\n        PREAMBLE2=\"10101010\" # 0x55 reverse\n        #AA = \"01101011011111011001000101110001\" #Access Address = 0x8E89BED6\n        \n        packet1 = PREAMBLE+AA\n        packet2 = PREAMBLE2+AA\n\n        if packet1 in bits_decode or packet2 in bits_decode :\n            if packet1 in bits_decode:\n                index = bits_decode.find(packet1)\n            else:\n                index = bits_decode.find(packet2)\n            \n            if len(bits_decode) - index >= 47*8:    # Drop packets\n                packets = bits_decode[index:index+47*8]\n            else:\n                #print(\"copy failed\")\n                return len(input_items[0])   \n                         \n            if packets[44*8:] == self.last_packets:  # Deduplication according to CRCs\n                return len(input_items[0]) \n            else:\n                self.last_packets=packets[44*8:]\n                \n                # Debug Log\n                '''\n                print(\"\\n[\",end='')\n                index=0\n                for i in range(0,47):\n                    Bytes=[packets[x] for x in range(index,index+4)]\n                    Bytes2=[packets[x] for x in range(index+4,index+8)]\n                    print(\"0x\"+format(int(\"\".join(Bytes2[::-1]),2),'x')+format(int(\"\".join(Bytes[::-1]),2),'x'),end=' ') # Bits need reverse\n                    index+=8                \n                print(\"]\")\n                '''\n                self.message_port_pub(pmt.intern(\"msg_out\"),pmt.intern(packets))\n                return len(input_items[0])\n        '''\n        \n        if packet2 in bits_decode:\n            index = bits_decode.find(packet2)\n            print(\"[\",end='')\n            for i in range(0,47):\n                try:\n                    Bytes=[bits_decode[x] for x in range(index,index+4)]\n                    Bytes2=[bits_decode[x] for x in range(index+4,index+8)]\n                    print(\"0x\"+format(int(\"\".join(Bytes2[::-1]),2),'x')+format(int(\"\".join(Bytes[::-1]),2),'x'),end=' ') # Bits need reverse\n                except:\n                    print(\"decode fail\")\n                    break    \n                index+=8\n            print(\"]\")\n        \n        '''\n        return len(input_items[0])\n        #return len(output_items[0])\n        #output_items[0][:] = input_items[0] * self.example_param\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    CHANNEL: channel_id
    _source_code: |-
      """
      Whiltening/De-Whitening Blocks:

      Inverse whitening of BLE data packets, so that we can parse the PDU format of the link layer then.

      Input data: Message data from BLE_Packets_Gain module
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Whiltening Blocks"""

          def __init__(self, CHANNEL=37):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Whiltening',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.message_port_register_out(pmt.intern('msg_out'))
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.channel = CHANNEL
              self.packets_pool=[]

          def handle_msg(self,msg):
              packets=pmt.symbol_to_string(msg)
              if packets in self.packets_pool:
                  if len(self.packets_pool) >100:
                      self.packets_pool=[]
                      #print("clear")
                  #print("pass")
                  return 0
              
              self.packets_pool.append(packets)
              index=0
              packets_after = self.whitening(self.channel,packets)
              self.message_port_pub(pmt.intern("msg_out"),pmt.intern(packets_after))
              """
              print("[Before Whitening]:",end='')
              self.logger(packets)
              print("[After   Whitening]:",end='')
              self.logger(packets_after)
              """
              time.sleep(0.01)
              

          def whitening(self,channel,data):
              pre = data[:40]
              data= data[40:]
              position=[]
              register=bin(channel)[2:].zfill(6)
              #print(register)
              position.append(1)
              for i in register:
                  position.append(int(i))
              #print("init position:"+"".join([str(x) for x in position]))

              sink=[]
              for x in data:
                  extra = position[6]
                  sink.append(extra^int(x))
                  position[6]=position[5]
                  position[5]=position[4]
                  position[4]=position[3]^extra
                  position[3]=position[2]
                  position[2]=position[1]
                  position[1]=position[0]
                  position[0]=extra
              return pre+"".join([str(x) for x in sink])

          def logger(self,data):
              index=0
              print("[",end='')
              for i in range(int(len(data)/8)):
                          Bytes=[data[x] for x in range(index,index+4)]
                          Bytes2=[data[x] for x in range(index+4,index+8)]
                          print(format(int("".join(Bytes2[::-1]),2),'x')+format(int("".join(Bytes[::-1]),2),'x'),end='') # Bits need reverse
                          #print("0x"+format(int("".join(Bytes),2),'x')+format(int("".join(Bytes2),2),'x'),end=' ') 
                          index+=8
              print("]")
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    CHANNEL: channel_id
    _source_code: |-
      """
      BLE_PDU_Decode Blocks:

      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import binascii

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Whiltening Blocks"""

          def __init__(self, CHANNEL = 37):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BLE PDU Decode',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              self.message_port_register_out(pmt.intern('msg_out'))
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.channel = CHANNEL
              self.output={'Channel':self.channel}

          def handle_msg(self,msg):
              packets=pmt.symbol_to_string(msg)
              packet_str = self.bit2str(packets) # Convert the bitstream to a string, modify the bits order
              
              len = self.PDU_Len(packet_str)
              packet_str = packet_str[:len*2+20] # minus the excess at the end

              # Start Parse PDU
              self.AA_Gain(packet_str)
              self.PDU_Payload(packet_str)
              self.PDU_CRC(packet_str)

              crc_ca=self.PDU_CRC_CAL(self.output['head']+self.output['payload']) #crc_ca=self.PDU_CRC_CAL(packet_str[10:len*2+14])
              
              if crc_ca !=int(self.output['crc'],base=16): # CRC Check
                  print("[LOG] Drop packets [CRC wrong]\n")
                  return 0
                  
              '''
              LOG
              '''
              print ("PACKETS —> ["+packet_str+"]")
              print ('    [CH]:'+str(self.channel),end=' ')
              print ('    [AA]:0x'+self.output['AA'].upper(),end='')
              if self.channel in [37,38,39]:
                  """Advertising Physical Channel PDU"""
                  self.PDU_ADV_Parse(packet_str) ## Parse Header
                  '''Log'''
                  try:
                      print ("    [Type]  : "+self.PDU_Type[self.output['type']],end=' ')
                      print ("    [ChSel] : "+self.PDU_CHSEL[self.output['ChSel']],end=' ')
                      print ("    [TxAdd] : "+self.PDU_Add[self.output['TxAdd']],end=' ')
                      print ("    [RxAdd] : "+self.PDU_Add[self.output['RxAdd']])
                  except:
                      print("Invaild PDU Header")
              else:
                  """Data Physical Channel PDU"""
                  print("Data Physical Channel PDU")
              
              print ("    [PAYLOAD] : ["+self.output['payload']+"]",end='')
              print ("    [LEN : "+str(len),end='')
              print ("    , CRC : "+self.output['crc']+"]\n")

              
              self.message_port_pub(pmt.intern("msg_out"),pmt.intern(str(self.output)))

          '''
          PDU Help Dict
          '''
          PDU_Type={
                  '0000':'ADV_IND',
                  '0001':'ADV_DIRECT_IND',
                  '0010':'ADV_NONCONN_IND',
                  '0011':'SCAN_REQ/AUX_SCAN_REQ',
                  '0100':'SCAN_RES',
                  '0101':'CONNECT_IND/AUX_CONNECT_REQ',
                  '0110':'ADV_SCAN_IND',
                  '0111':'ADV_EXT_IND',   #AUX_ADV_IND/AUX_SCAN_RSP/AUX_SYNC_IND/AUX_CHAIN_IND
                  '1000':'AUX_CONNECT_RSP'
              }
          PDU_Add={
                  '0':'Public',
                  '1':'Random'
              }
          PDU_CHSEL={
                  '0':'#1',
                  '1':'#2'
              }
              
          '''
          Bits to String
          Reverse the byte order of the bit stream and convert it to string format
          The endianness is the same as wireshark shows.
          '''
          def bit2str(self,data):
              str=""
              index=0
              for i in range(int(len(data)/8)):
                  Bytes=[data[x] for x in range(index,index+4)]
                  Bytes2=[data[x] for x in range(index+4,index+8)]
                  str+=format(int("".join(Bytes2[::-1]),2),'x')+format(int("".join(Bytes[::-1]),2),'x') # Bits need reverse
                  index+=8
              return str

          """
          Access Address Gain
          """
          def AA_Gain(self,data):
              data_lsb = data[2:10]
              aa = self.lsb2value(data_lsb)
              #for i in range(4): 
              #    aa += data_lsb[(3-i)*2]+data_lsb[(3-i)*2+1]
              self.output['AA']=aa
              #return aa

          '''
          PDU payload len Gain
          '''
          def PDU_Len(self,data):
              #data_lsb = data[10:12]
              data_lsb = data[12:14]
              pdu_len = self.lsb2value(data_lsb)
              return int(pdu_len,base=16)

          '''
          PDU Type && RFU && ChSel && TxAdd && RxAdd
          '''
          def PDU_ADV_Parse(self,data):
              data_lsb = data[10:12]
              pdu_type = bin(int(data_lsb[1],base=16))[2:].zfill(4)
              bits = bin(int(data_lsb[0],base=16))[2:].zfill(4)[::-1]  #fix endianness
              pdu_rfu = bits[0]
              pdu_ChSel = bits[1]
              pdu_TxAdd = bits[2]
              pdu_RxAdd = bits[3]
              ## Return
              self.output['type']=pdu_type 
              self.output['rfu']=pdu_rfu
              self.output['ChSel']=pdu_ChSel
              self.output['TxAdd']=pdu_TxAdd
              self.output['RxAdd']=pdu_RxAdd

              
          def PDU_Payload(self,data):
              self.output['head']=data[10:14] # PDU header
              self.output['payload']=data[14:-6]  # PDU payload

          '''
          PDU CRC Gain
          '''
          def PDU_CRC(self,data):
              crc = data[-6:]
              crc_re=""
              #for i in range(len(crc)):       
                  #crc_re+=hex(int(bin(int(crc[i],base=16))[2:].zfill(4)[::-1],2))[2:]
              #print(crc)
              for i in range(3):
                  crc_re+=crc[(2-i)*2]+crc[(2-i)*2+1]
              self.output['crc'] ="0x" + crc_re

          def PDU_CRC_CAL(self,data,crcinit=0x555555):
              data_re=""
              #Restoring the byte order to the original order during Bluetooth transmission 
              #is actually a bit redundant and worth optimizing.
              for i in range(int(len(data)/2)):
                  data_re +=hex(int((bin(int(data[i*2],base=16))[2:].zfill(4) + bin(int(data[i*2+1],base=16))[2:].zfill(4))[::-1],base=2) )[2:].zfill(2)
              payload = binascii.unhexlify(data_re)
              crc24 = self.crc24(payload,crcinit)
              return int(bin(crc24)[2:].zfill(24)[::-1],2) # reverse bits

          def crc24(self,octets,crcint):
              INIT = crcint
              POLY = 0x100065B
              crc = INIT
              for octet in octets: # this is what the '*octets++' logic is effectively
              # accomplishing in the C code.
                  crc ^= (octet << 16)
                  # Throw that ROL function away, because the C code **doesn't** actually
                  # rotate left; it shifts left. It happens to throw away any bits that are
                  # shifted past the 32nd position, but that doesn't actulaly matter for
                  # the correctness of the algorithm, because those bits can never "come back"
                  # and we will mask off everything but the bottom 24 at the end anyway.
                  for i in range(8):
                      crc <<= 1
                      if crc & 0x1000000: crc ^= POLY
              return crc & 0xFFFFFF


          '''
          Parse the little-endian data byte sequence to get the real value of this field
          (provided that the metadata comes from bit2str)
          '''
          def lsb2value(self,data):
              length = int(len(data)/2)
              str=""
              for i in range(length): 
                  str += data[(length-1-i)*2]+data[(length-1-i)*2+1]
              return str
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: 2e6
    freq0: freq_channel
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_demod_0, '0', epy_block_0, '0']
- [epy_block_0, msg_out, epy_block_1, msg_in]
- [epy_block_1, msg_out, epy_block_2, msg_in]
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
